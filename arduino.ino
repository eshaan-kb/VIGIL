// AGRICLOUD standalone menu: native Hindi/Kannada bitmap labels embedded; ST7920 SW SPI
// Bitmap glyphs generated from Noto Sans Devanagari/Kannada at 14 px for improved readability.
#include <Arduino.h>
#include <U8g2lib.h>
#include <ArduinoBLE.h>

// ================================================
// AGRICLOUD
// Arduino UNO R4 WiFi + ST7920 128x64
// ================================================

#define LCD_CLOCK 13
#define LCD_DATA  11
#define LCD_CS   10

U8G2_ST7920_128X64_1_SW_SPI u8g2(
  U8G2_R0, LCD_CLOCK, LCD_DATA, LCD_CS, U8X8_PIN_NONE
);

#define NAV_PIN     A0
#define BUTTON_PIN  5
#define BUZZER_PIN 8

// BLE interface used by the VIGIL website
#define DEVICE_NAME "VIGIL"
#define VIGIL_SERVICE_UUID "7c6a0001-8f3b-4a2d-9c5e-123456789001"
#define VIGIL_CHARACTERISTIC_UUID "7c6a0002-8f3b-4a2d-9c5e-123456789001"

BLEService vigilService(VIGIL_SERVICE_UUID);
BLEStringCharacteristic vigilCharacteristic(
  VIGIL_CHARACTERISTIC_UUID, BLERead | BLEWrite, 180
);
bool bleReady = false;

const int RESOURCE_COUNT = 7;
const int LANGUAGE_COUNT = 3;

const unsigned long DEBOUNCE_DELAY = 40;
const unsigned long NAV_STABILITY_TIME = 65;

enum Screen {
  HOME,
  RESOURCES,
  LANGUAGES,
  HISTORY,
  RESOURCE_DETAILS,
  HISTORY_VIEW,
  ALERT_PAGE
};

enum Language {
  ENGLISH,
  HINDI,
  KANNADA
};

Screen screen = HOME;
Language language = ENGLISH;

int selection = 0;
int selectedResource = 0;

bool alertActive = false;

String alertHeading = "MAJOR ALERT";
String alertMessage = "Agricultural impact detected";

String impactEvent = "No impact event";
String historyMessage = "No history available";

// Indicative reference prices (INR), normalized to usable display units.
// Snapshot date: 24 Nov 2026. Crop values are indicative mandi benchmarks;
// urea is converted from the notified 45 kg bag MRP; diesel is Bengaluru retail.
// Order: Rice, Wheat, Maize, Tur/Arhar whole, Urea, Diesel, Cotton.
float currentPrices[RESOURCE_COUNT] = {
  34.03, 26.00, 25.00, 85.00, 5.38, 99.56, 87.00
};

// Historical comparison values have not been verified. Zero means unavailable;
// the LCD will show N/A instead of displaying an invented previous price/change.
float previousPrices[RESOURCE_COUNT] = {
  0.00, 0.00, 0.00, 0.00, 0.00, 99.56, 0.00
};

const char* priceUnits[RESOURCE_COUNT] = {
  "/kg", "/kg", "/kg", "/kg", "/kg", "/L", "/kg"
};


bool lastButtonReading = HIGH;
bool stableButtonState = HIGH;
unsigned long lastDebounceTime = 0;

int filteredValue = 0;
int candidateSelection = -1;
unsigned long candidateStartTime = 0;
bool navigationInitialized = false;

// ================================================
// RESOURCE NAMES
// ================================================

const char* resourcesEN[] = {
  "Rice", "Wheat", "Maize", "Pulses",
  "Fertilizer", "Fuel", "Cotton"
};

const char* resourcesHI[] = {
  "चावल", "गेहूँ", "मक्का", "दालें",
  "उर्वरक", "ईंधन", "कपास"
};

const char* resourcesKN[] = {
  "ಅಕ್ಕಿ", "ಗೋಧಿ", "ಮೆಕ್ಕೆಜೋಳ", "ಬೇಳೆಕಾಳು",
  "ರಸಗೊಬ್ಬರ", "ಇಂಧನ", "ಹತ್ತಿ"
};

// ================================================
// LANGUAGE NAMES
// ================================================

const char* languagesEN[] = {
  "English", "Hindi", "Kannada"
};

const char* languagesHI[] = {
  "अंग्रेज़ी", "हिन्दी", "कन्नड़"
};

const char* languagesKN[] = {
  "ಇಂಗ್ಲಿಷ್", "ಹಿಂದಿ", "ಕನ್ನಡ"
};


// Refined native-script bitmaps rendered from Noto Sans Devanagari and Kannada,
// using supersampling before monochrome conversion for cleaner strokes.
const uint8_t langBmp0[] PROGMEM = {0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x86, 0x01, 0x0B, 0x00, 0x00, 0x00, 0x01, 0x13, 0x00, 0x70, 0xFE, 0xFF, 0x3F, 0x00, 0xC0, 0x26, 0x03, 0x12, 0x00, 0xC0, 0x22, 0xC1, 0x13, 0x00, 0xE8, 0x32, 0xC9, 0x12, 0x00, 0x88, 0x33, 0x89, 0x12, 0x00, 0x90, 0x26, 0xD1, 0x12, 0x00, 0x60, 0xC6, 0x61, 0x12, 0x00, 0x00, 0x62, 0x01, 0x12, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00};
const uint8_t langBmp1[] PROGMEM = {0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x00, 0x00, 0x02, 0x01, 0x00, 0x00, 0xFC, 0xFF, 0xFF, 0xFF, 0x3F, 0x60, 0x06, 0x83, 0x09, 0x19, 0x78, 0x06, 0xE2, 0x09, 0x11, 0x0C, 0xE6, 0x13, 0xC8, 0x11, 0x3C, 0x36, 0xF3, 0xC8, 0x1F, 0x78, 0x16, 0xF2, 0xC9, 0x10, 0xC0, 0x36, 0x12, 0x89, 0x11, 0x7C, 0x66, 0x92, 0x09, 0x13, 0x70, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00};
const uint8_t langBmp2[] PROGMEM = {0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x0D, 0x00, 0x8C, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x04, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0xF8, 0xFF, 0xFF, 0xFF, 0x7F, 0xF8, 0xFF, 0xFF, 0xF1, 0xFF, 0x07, 0x80, 0x0D, 0x04, 0x32, 0x66, 0x60, 0xB6, 0x19, 0x00, 0x02, 0x06, 0xF0, 0x08, 0xC4, 0x13, 0x22, 0x20, 0x22, 0x11, 0xC0, 0x03, 0x02, 0x10, 0xCC, 0x67, 0x90, 0x23, 0x38, 0x32, 0x71, 0x60, 0x9E, 0x03, 0xF0, 0x68, 0xE4, 0x91, 0x3F, 0xF8, 0x33, 0x99, 0x20, 0xB6, 0x01, 0xE0, 0x6D, 0xE4, 0x13, 0x21, 0x10, 0x32, 0x9F, 0x60, 0xB3, 0x01, 0x00, 0x49, 0x24, 0x16, 0x22, 0x20, 0x22, 0x98, 0xC0, 0x13, 0x03, 0xF0, 0xCC, 0x24, 0x12, 0x24, 0x40, 0x32, 0x91, 0x00, 0x12, 0x06, 0xE0, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00};
const uint8_t langBmp3[] PROGMEM = {0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7C, 0xF2, 0x1F, 0x60, 0xF7, 0x1F, 0x38, 0x35, 0x08, 0x04, 0xB7, 0x0F, 0x1C, 0xB2, 0x09, 0x78, 0x33, 0x09, 0x60, 0x3E, 0x08, 0x3C, 0x20, 0x08, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00};
const uint8_t langBmp4[] PROGMEM = {0x00, 0x60, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0xFE, 0xFF, 0xFF, 0x7F, 0x40, 0x60, 0x0C, 0x06, 0x40, 0x3C, 0xCC, 0x07, 0x60, 0x22, 0x67, 0x3E, 0x66, 0x22, 0x63, 0x26, 0xC4, 0x3E, 0xC2, 0x27, 0xC8, 0x2C, 0x84, 0x37, 0x70, 0x20, 0x08, 0x06, 0x00, 0x00, 0x00, 0x00};
const uint8_t langBmp5[] PROGMEM = {0xFC, 0xFF, 0xFF, 0x01, 0xE4, 0x8F, 0xCF, 0x01, 0x50, 0x00, 0xE1, 0x00, 0xDC, 0xF9, 0x11, 0x00, 0xC4, 0x92, 0x71, 0x00, 0x7C, 0xC2, 0xA1, 0x00, 0x58, 0x62, 0x89, 0x01, 0x40, 0x60, 0xF1, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00};
const uint8_t langBmp6[] PROGMEM = {0xFC, 0xFF, 0xFF, 0x1F, 0xC8, 0xFF, 0xFF, 0x1F, 0xF0, 0x30, 0x09, 0x09, 0xD8, 0x33, 0xC9, 0x09, 0x88, 0x36, 0xC9, 0x0F, 0xF8, 0xE4, 0xC9, 0x08, 0xF0, 0x06, 0x89, 0x09, 0x80, 0x00, 0x09, 0x0B, 0x00, 0x00, 0x00, 0x00};
const uint8_t langBmp7[] PROGMEM = {0x00, 0x00, 0x00, 0x00, 0x30, 0x24, 0x20, 0x38, 0x60, 0x00, 0xFC, 0x3F, 0x48, 0x1C, 0x48, 0x03, 0x4C, 0x0E, 0x48, 0x1B, 0x40, 0x11, 0x40, 0x02, 0x00, 0x0E, 0x00, 0x32, 0x00, 0x26, 0x00, 0x00, 0x00, 0x00};
const uint8_t langBmp8[] PROGMEM = {0xFC, 0xFF, 0xFF, 0x0F, 0x80, 0x3F, 0x9E, 0x07, 0x80, 0x8D, 0x02, 0x06, 0xB8, 0xED, 0xF6, 0x07, 0x90, 0x2D, 0x96, 0x06, 0xF0, 0xED, 0x13, 0x06, 0xE0, 0x8D, 0x27, 0x06, 0x80, 0x0D, 0x42, 0x06, 0x00, 0x00, 0x00, 0x00};
const uint8_t langBmp9[] PROGMEM = {0x00, 0x00, 0x00, 0x00, 0xC0, 0x04, 0x00, 0x00, 0x07, 0x00, 0x00, 0x02, 0xFC, 0xFF, 0x07, 0xE4, 0xDF, 0x07, 0x30, 0x02, 0x02, 0x1C, 0xF2, 0x03, 0x04, 0xDA, 0x02, 0x6C, 0x1A, 0x02, 0x78, 0x32, 0x02, 0x40, 0x22, 0x02, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00};
const uint8_t langBmp10[] PROGMEM = {0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x07, 0x00, 0x00, 0x00, 0x10, 0x06, 0x00, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x00, 0x10, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x10, 0x00, 0x00, 0x00, 0xF8, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xB0, 0x19, 0x18, 0x60, 0x02, 0x4C, 0x60, 0xB0, 0x31, 0x03, 0x90, 0x98, 0x19, 0x60, 0x02, 0x4F, 0x60, 0x1E, 0x31, 0x03, 0x90, 0xD8, 0x24, 0x7F, 0x82, 0x41, 0x7C, 0x83, 0x3D, 0x03, 0x90, 0xD9, 0xAD, 0x6D, 0x82, 0x47, 0x66, 0x0E, 0xFD, 0x01, 0x10, 0x9F, 0xB9, 0x61, 0x02, 0x4F, 0x62, 0xBE, 0x09, 0x03, 0x10, 0x98, 0x30, 0x63, 0x02, 0x48, 0x66, 0xA1, 0x11, 0x03, 0x10, 0x98, 0x1F, 0x66, 0x82, 0x4F, 0x6C, 0x93, 0x21, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00};
const uint8_t langBmp11[] PROGMEM = {0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x07, 0xD8, 0x0C, 0x0C, 0x30, 0x81, 0x09, 0x60, 0x03, 0x48, 0xCC, 0x0C, 0x30, 0x81, 0x08, 0x20, 0x03, 0x48, 0x6C, 0x92, 0x3F, 0x81, 0xC8, 0x3F, 0x03, 0xC8, 0xEC, 0xD6, 0x36, 0xC1, 0x4F, 0x12, 0x03, 0x88, 0xCF, 0xDC, 0x30, 0xC1, 0x48, 0xF0, 0x03, 0x08, 0x4C, 0x98, 0x31, 0x01, 0xC8, 0xE0, 0x03, 0x08, 0xCC, 0x0F, 0x33, 0x01, 0x88, 0x01, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x32, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x42, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00};
const uint8_t langBmp12[] PROGMEM = {0xFC, 0xC5, 0xFF, 0x07, 0xFC, 0xCE, 0x1F, 0x03, 0xC8, 0x9E, 0xC4, 0x03, 0xC8, 0x98, 0x64, 0x03, 0xC8, 0xF8, 0x34, 0x03, 0xF8, 0x98, 0xE4, 0x03, 0xD8, 0x80, 0xC4, 0x03, 0xCC, 0x80, 0x04, 0x02, 0x00, 0x00, 0x00, 0x00};
const uint8_t langBmp13[] PROGMEM = {0xFE, 0xFF, 0xFF, 0xFF, 0x03, 0xFE, 0xFF, 0xFF, 0xDF, 0x03, 0x50, 0x10, 0x40, 0x42, 0x01, 0x5C, 0x1C, 0x7F, 0x72, 0x01, 0x56, 0x02, 0x59, 0x12, 0x01, 0x74, 0x22, 0x49, 0x12, 0x01, 0x7C, 0x7E, 0x43, 0xF2, 0x01, 0x40, 0x38, 0x46, 0x02, 0x03, 0x00, 0x60, 0x44, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00};
const uint8_t langBmp14[] PROGMEM = {0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x9C, 0xFF, 0xFF, 0x3F, 0x00, 0x3C, 0xC9, 0x24, 0x11, 0x00, 0x38, 0x49, 0x25, 0x11, 0x00, 0xF0, 0x49, 0x26, 0x11, 0x00, 0x30, 0xC9, 0x26, 0x0B, 0x00, 0x00, 0x89, 0x25, 0x06, 0x00, 0x00, 0x09, 0x24, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00};
const uint8_t langBmp15[] PROGMEM = {0xFE, 0xFF, 0xFF, 0x1F, 0xFC, 0xE7, 0xF3, 0x1F, 0x88, 0x58, 0x2C, 0x08, 0x88, 0x7C, 0xFF, 0x08, 0xFC, 0xC6, 0xE3, 0x09, 0xDC, 0x64, 0x32, 0x09, 0x88, 0x7C, 0x3E, 0x09, 0x80, 0x40, 0x20, 0x09, 0x80, 0x40, 0x20, 0x08};
const uint8_t langBmp16[] PROGMEM = {0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x0F, 0x80, 0xC0, 0xCC, 0x06, 0x03, 0x19, 0x40, 0x06, 0xF0, 0xC0, 0x4C, 0x04, 0x02, 0x11, 0x40, 0x06, 0x88, 0xF8, 0xCC, 0xE6, 0x03, 0x91, 0x7F, 0x06, 0x8C, 0xCC, 0x7E, 0x76, 0x83, 0x9F, 0x24, 0x06, 0xC8, 0xC4, 0xCE, 0x26, 0x82, 0x91, 0xE0, 0x03, 0xF0, 0xCC, 0xC0, 0x06, 0x02, 0x90, 0xC1, 0x06, 0x80, 0xD8, 0xC0, 0x06, 0x02, 0x10, 0x03, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x64, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x84, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00};
const uint8_t langBmp17[] PROGMEM = {0xFC, 0xFF, 0xFF, 0x07, 0xC0, 0xFF, 0xFF, 0x03, 0xF0, 0x24, 0x23, 0x03, 0xD8, 0x24, 0x3B, 0x03, 0xCC, 0x24, 0xFB, 0x03, 0xF8, 0xE4, 0x13, 0x03, 0xF0, 0x04, 0x23, 0x03, 0x80, 0x04, 0x43, 0x03, 0x00, 0x00, 0x00, 0x00};
const uint8_t langBmp18[] PROGMEM = {0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0xFF, 0x3F, 0xFB, 0x3F, 0x90, 0x31, 0x93, 0x12, 0x18, 0x10, 0x21, 0x93, 0x10, 0x08, 0x1C, 0x39, 0x93, 0x93, 0x0F, 0xFC, 0xF9, 0x13, 0x91, 0x0B, 0x0C, 0x19, 0x13, 0x99, 0x09, 0x18, 0x31, 0x13, 0x1F, 0x08, 0x30, 0x61, 0x13, 0x10, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00};
const uint8_t langBmp19[] PROGMEM = {0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x78, 0x00, 0x84, 0x01, 0x4C, 0x00, 0x04, 0x03, 0x8C, 0x00, 0xFE, 0xFF, 0xFF, 0x01, 0x0C, 0x02, 0x88, 0x01, 0xC4, 0x03, 0x8C, 0x00, 0x64, 0xF0, 0x87, 0x00, 0xE4, 0xB1, 0x81, 0x00, 0xE4, 0x33, 0x99, 0x00, 0x24, 0x06, 0x9F, 0x00, 0x24, 0x02, 0x98, 0x00, 0x40, 0x00, 0x10, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00};
const uint8_t langBmp20[] PROGMEM = {0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xA0, 0x01, 0x9C, 0xE3, 0x01, 0xB4, 0x86, 0x00, 0xBE, 0xF5, 0x03, 0xC6, 0x35, 0x01, 0x04, 0x16, 0x03, 0xFC, 0xF3, 0x01, 0xF0, 0xE0, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x12, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00};
const uint8_t langBmp21[] PROGMEM = {0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x98, 0x01, 0x20, 0x00, 0x70, 0x03, 0x78, 0xF9, 0x7F, 0x00, 0xD8, 0xE4, 0xB1, 0x83, 0xB4, 0x00, 0x10, 0x34, 0x1B, 0x83, 0xED, 0x00, 0xC0, 0x15, 0x0A, 0x73, 0x0A, 0x00, 0x20, 0x17, 0x0A, 0x0B, 0x0E, 0x00, 0x20, 0x36, 0x0B, 0x9B, 0x0D, 0x00, 0xE0, 0xE5, 0x09, 0x72, 0x0E, 0x00, 0x00, 0x00, 0x80, 0x04, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x40, 0x0D, 0x00, 0x00, 0x00, 0x00, 0x40, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00};
const uint8_t langBmp22[] PROGMEM = {0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x02, 0x00, 0x00, 0x00, 0x02, 0x02, 0x00, 0x00, 0x00, 0x03, 0x02, 0xFC, 0x73, 0xFC, 0xF9, 0x01, 0x6C, 0xDA, 0x0C, 0x01, 0x01, 0x00, 0x8A, 0x05, 0x12, 0x02, 0xF0, 0x0A, 0x05, 0x3A, 0x02, 0x98, 0x8B, 0x65, 0x6E, 0x02, 0xF0, 0xF3, 0xFC, 0xCB, 0x03, 0x20, 0x22, 0x60, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00};
const uint8_t langBmp23[] PROGMEM = {0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x01, 0x00, 0xF0, 0x01, 0x00, 0x00, 0x02, 0x00, 0xB1, 0x01, 0x00, 0x00, 0x03, 0xF8, 0x63, 0xFB, 0xFF, 0xFC, 0x01, 0x48, 0xC4, 0x83, 0x80, 0x21, 0x01, 0x00, 0x44, 0xF3, 0x0F, 0x19, 0x03, 0xE0, 0xD7, 0x8B, 0x68, 0x3D, 0x02, 0x30, 0x13, 0x8A, 0x38, 0x25, 0x02, 0xE0, 0xF3, 0xFB, 0xEF, 0xCD, 0x01, 0x40, 0x46, 0x20, 0x42, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00};
const uint8_t langBmp24[] PROGMEM = {0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0xC0, 0x01, 0x00, 0x00, 0x00, 0x80, 0x07, 0x00, 0x00, 0x08, 0x00, 0x40, 0xE3, 0x00, 0x00, 0x80, 0x80, 0x0E, 0x00, 0x00, 0x08, 0x00, 0xC0, 0xA7, 0x01, 0x00, 0xC0, 0x1F, 0xCB, 0xFF, 0xE7, 0x07, 0xDE, 0x7B, 0xC4, 0x01, 0x00, 0x60, 0x12, 0x0E, 0x02, 0x04, 0x09, 0x52, 0x6A, 0xC4, 0x04, 0x00, 0x00, 0x10, 0xCF, 0x3F, 0x4C, 0x09, 0xFE, 0x1A, 0x26, 0x04, 0x00, 0x80, 0x57, 0x5F, 0xE6, 0xE9, 0x08, 0xE2, 0xF2, 0x73, 0x04, 0x00, 0x80, 0xD8, 0x58, 0xE6, 0xAD, 0x09, 0x06, 0xA3, 0xD9, 0x04, 0x00, 0x80, 0x9F, 0xCF, 0xBF, 0x27, 0x0F, 0xFC, 0xE1, 0x91, 0x07, 0x00, 0x00, 0x12, 0x02, 0x00, 0x00, 0x00, 0x20, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00};
const uint8_t langBmp25[] PROGMEM = {0x00, 0x00, 0x00, 0x00, 0x40, 0x80, 0x00, 0x02, 0x80, 0x80, 0x01, 0x04, 0x80, 0x80, 0x01, 0x04, 0x7C, 0xFE, 0xF8, 0x03, 0x30, 0x40, 0x18, 0x03, 0xFC, 0x80, 0x88, 0x07, 0xCC, 0x8E, 0x89, 0x07, 0x84, 0x92, 0x49, 0x04, 0x7C, 0xF2, 0xF8, 0x06, 0x30, 0x62, 0x32, 0x03, 0x00, 0xC0, 0x06, 0x00, 0x00, 0xE0, 0x03, 0x00, 0x00, 0xE0, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00};
const uint8_t langBmp26[] PROGMEM = {0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x00, 0x3F, 0x00, 0x80, 0x01, 0x00, 0x61, 0x00, 0xFC, 0xF0, 0x78, 0xFF, 0x00, 0xC8, 0x18, 0x49, 0xE3, 0x00, 0x8C, 0x08, 0x7B, 0xC1, 0x00, 0x84, 0x49, 0x3A, 0x81, 0x00, 0x84, 0x69, 0x0A, 0x89, 0x00, 0x84, 0xEF, 0x19, 0xFF, 0x00, 0x04, 0xC7, 0x30, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00};
const uint8_t langBmp27[] PROGMEM = {0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x98, 0x07, 0x00, 0x00, 0x20, 0x00, 0x00, 0xD0, 0x0C, 0x00, 0x00, 0x20, 0x00, 0xE0, 0xDF, 0xCA, 0xFF, 0xC3, 0x3F, 0x00, 0xE0, 0x8F, 0xDF, 0xFF, 0xCF, 0x1F, 0x03, 0x00, 0xD9, 0xD8, 0x7F, 0x08, 0x30, 0x02, 0x60, 0x50, 0x50, 0x44, 0xD8, 0x21, 0x06, 0xB0, 0x50, 0xD0, 0x58, 0x53, 0x21, 0x04, 0x30, 0xD3, 0x48, 0x6C, 0x49, 0x66, 0x06, 0xE0, 0x8F, 0xCF, 0x39, 0xCF, 0xFF, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00};
const uint8_t langBmp28[] PROGMEM = {0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x20, 0x00, 0x08, 0x80, 0x03, 0x0E, 0x00, 0x0C, 0x60, 0x00, 0x08, 0xC0, 0x06, 0x1B, 0x00, 0x0C, 0x60, 0x00, 0x08, 0x00, 0x06, 0x18, 0xFC, 0xC7, 0x3F, 0xE3, 0x0F, 0xDE, 0xE3, 0x0E, 0x00, 0x00, 0x04, 0x06, 0x04, 0x12, 0x91, 0x08, 0xC0, 0x04, 0x24, 0x04, 0x0F, 0x12, 0x92, 0x18, 0x38, 0x8C, 0x63, 0x8C, 0x0D, 0x0C, 0x76, 0x10, 0x2C, 0xC8, 0x43, 0x2C, 0x1F, 0x04, 0x16, 0x18, 0xCC, 0xCC, 0x64, 0x64, 0x08, 0x66, 0x36, 0x08, 0xF8, 0xB7, 0xFC, 0xC7, 0x0F, 0xFC, 0xE3, 0x0F, 0x00, 0x22, 0x10, 0x01, 0x01, 0x08, 0x00, 0x01, 0x00, 0x20, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x14, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00};
const uint8_t langBmp29[] PROGMEM = {0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x80, 0x07, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x80, 0x04, 0x10, 0x00, 0x30, 0x02, 0x00, 0xC0, 0x00, 0x06, 0x38, 0xE3, 0x9F, 0xF7, 0x8F, 0x7F, 0xFE, 0x03, 0x6C, 0x46, 0x90, 0x44, 0x18, 0x60, 0xDC, 0x03, 0x20, 0x6C, 0xB0, 0xC7, 0x30, 0xC0, 0x62, 0x06, 0x18, 0x28, 0xA0, 0x83, 0xB6, 0x83, 0x8E, 0x05, 0x08, 0x28, 0xA2, 0xC0, 0xB6, 0x8A, 0xCE, 0x05, 0xC8, 0x6C, 0xB7, 0x61, 0x92, 0xD8, 0x42, 0x06, 0x78, 0xC7, 0x1D, 0x3F, 0x9E, 0x77, 0x9E, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00};
const uint8_t langBmp30[] PROGMEM = {0x00, 0x02, 0x80, 0x01, 0x00, 0x00, 0x00, 0x80, 0x07, 0xC0, 0x03, 0x00, 0x80, 0x00, 0x80, 0x0D, 0x40, 0x02, 0x00, 0x00, 0x01, 0x10, 0x0C, 0x00, 0x03, 0x00, 0x84, 0x01, 0xBC, 0xE7, 0xBD, 0xFB, 0x3F, 0xEE, 0x0C, 0x24, 0x26, 0x25, 0x42, 0x60, 0x9B, 0x19, 0x30, 0xE4, 0x1D, 0xFA, 0x43, 0x0F, 0x11, 0x18, 0xEC, 0x0C, 0x13, 0xD9, 0x86, 0x30, 0x4C, 0x2C, 0xF0, 0x19, 0xDB, 0xFC, 0x31, 0xCC, 0x6C, 0xB0, 0x10, 0x49, 0x68, 0x13, 0xB8, 0xC7, 0xF0, 0xF0, 0x79, 0x38, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00};
const uint8_t langBmp31[] PROGMEM = {0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x08, 0x10, 0x00, 0x00, 0x00, 0x00, 0x09, 0x08, 0x30, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x08, 0x30, 0x00, 0xBC, 0xFF, 0xFC, 0xE7, 0xCF, 0x9D, 0x01, 0x24, 0x86, 0x01, 0xC0, 0x64, 0x13, 0x03, 0x24, 0x04, 0xC1, 0x4C, 0xEC, 0x21, 0x02, 0x18, 0x0C, 0x3B, 0x69, 0xC8, 0x30, 0x02, 0x08, 0x6C, 0x2F, 0x6B, 0x88, 0x1F, 0x06, 0xCC, 0x2C, 0xCD, 0x2E, 0x08, 0x3D, 0x02, 0xF8, 0xE7, 0xF9, 0x2F, 0x08, 0xEF, 0x03, 0xD0, 0x40, 0x00, 0x0C, 0x00, 0x82, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00};
const uint8_t langBmp32[] PROGMEM = {0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x08, 0x80, 0x09, 0x90, 0x00, 0x1B, 0x00, 0x00, 0x18, 0x00, 0x0C, 0x80, 0x00, 0x08, 0x00, 0x00, 0x18, 0xFC, 0x67, 0x7E, 0x78, 0x0F, 0x0F, 0xE7, 0x0E, 0x00, 0xC6, 0x30, 0xC8, 0x8C, 0x91, 0x9D, 0x08, 0x00, 0x84, 0xFC, 0xC8, 0x87, 0xB0, 0xF5, 0x18, 0x38, 0x8C, 0xCD, 0x30, 0x80, 0xA4, 0x77, 0x08, 0x2C, 0x88, 0xC5, 0x10, 0x88, 0xA6, 0xE0, 0x0F, 0xCC, 0x8C, 0xC4, 0x98, 0x99, 0x32, 0xC1, 0x06, 0xF8, 0xFF, 0x7C, 0xF2, 0xFF, 0x1E, 0x83, 0x03, 0x00, 0x22, 0x10, 0x22, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x80, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x05, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00};
const uint8_t langBmp33[] PROGMEM = {0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x84, 0x07, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x84, 0x04, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x04, 0x04, 0x00, 0x00, 0x40, 0x00, 0xF0, 0xF3, 0xF7, 0xC3, 0xE7, 0x0C, 0x3F, 0x00, 0x30, 0x82, 0x60, 0x42, 0x2C, 0x19, 0x23, 0x00, 0x10, 0x84, 0x24, 0x66, 0x88, 0x30, 0x41, 0x00, 0x10, 0x74, 0x34, 0x64, 0x49, 0x30, 0x41, 0x00, 0x10, 0xD6, 0x34, 0xE4, 0x29, 0x32, 0x61, 0x00, 0xE0, 0x93, 0x37, 0x3C, 0xED, 0x1F, 0x3E, 0x00, 0xC0, 0x11, 0x03, 0x3C, 0xC7, 0xCC, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x9C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x9C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00};
const uint8_t langBmp34[] PROGMEM = {0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x08, 0x30, 0x00, 0x00, 0x00, 0x10, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x10, 0x20, 0x00, 0x00, 0x00, 0x10, 0x40, 0x00, 0x00, 0x04, 0x00, 0x18, 0x30, 0x10, 0x40, 0x00, 0x10, 0x61, 0x00, 0xF8, 0xC7, 0xF9, 0xCF, 0x1F, 0x7C, 0xE0, 0xCC, 0x8F, 0x3B, 0x03, 0x80, 0xE0, 0x03, 0x08, 0x10, 0xC6, 0x90, 0x99, 0xC8, 0x66, 0x06, 0x80, 0x24, 0x86, 0x09, 0x30, 0x82, 0xF0, 0xD0, 0xD0, 0x43, 0x04, 0x70, 0x34, 0x76, 0xD8, 0x21, 0x92, 0x70, 0xD0, 0x90, 0x21, 0x0C, 0x58, 0x3C, 0x5E, 0x51, 0x22, 0x9A, 0x10, 0xD8, 0x10, 0x7F, 0x0C, 0x88, 0x24, 0x9A, 0x59, 0x66, 0xCA, 0x60, 0x4C, 0x10, 0xDA, 0x04, 0x98, 0xC7, 0xF3, 0x4E, 0xFC, 0x7B, 0xC2, 0x47, 0x10, 0x8E, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x05, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00};
const uint8_t langBmp35[] PROGMEM = {0x00, 0x00, 0x00, 0x00, 0x22, 0x00, 0x00, 0xF6, 0x00, 0x00, 0xD2, 0x01, 0xFC, 0x63, 0x01, 0x20, 0xC0, 0x01, 0xFC, 0xE3, 0x01, 0x64, 0xEE, 0x03, 0x64, 0x1E, 0x03, 0xFC, 0xF3, 0x01, 0x00, 0x40, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0D, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x00};
const uint8_t langBmp36[] PROGMEM = {0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0xF8, 0x00, 0x68, 0x00, 0x08, 0x01, 0x78, 0x00, 0xE8, 0x03, 0x70, 0xF0, 0x39, 0x03, 0xB8, 0x13, 0x09, 0x06, 0xEC, 0x16, 0x0D, 0x06, 0x44, 0x14, 0x4D, 0x04, 0xEC, 0xB6, 0xE9, 0x06, 0xB8, 0xE3, 0xB8, 0x03, 0x00, 0x00, 0x00, 0x00};
const uint8_t langBmp37[] PROGMEM = {0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x40, 0x00, 0x40, 0x00, 0x00, 0x00, 0x02, 0x00, 0x80, 0x07, 0x80, 0x19, 0x40, 0x00, 0xE0, 0x01, 0x00, 0x00, 0x02, 0x00, 0x80, 0x06, 0x80, 0x30, 0x40, 0x20, 0xA0, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x07, 0x8E, 0x7F, 0x3F, 0xF0, 0xC7, 0xF2, 0xFF, 0xF9, 0x01, 0x00, 0x00, 0x03, 0x9B, 0x61, 0x20, 0x98, 0x84, 0x83, 0x00, 0x41, 0x02, 0x00, 0x80, 0x7F, 0xB1, 0x40, 0x42, 0x00, 0xC4, 0xF3, 0x0F, 0x53, 0x02, 0x00, 0xC0, 0x4C, 0xA1, 0x40, 0x47, 0xE0, 0xD5, 0x97, 0x79, 0x3A, 0x02, 0x00, 0xC0, 0x44, 0xB1, 0xCC, 0x4D, 0x20, 0x36, 0x96, 0x79, 0x6B, 0x02, 0x00, 0x80, 0x7F, 0x9E, 0x3F, 0x79, 0xE0, 0xE7, 0xF3, 0xEF, 0xC9, 0x03, 0x00, 0x00, 0x01, 0x04, 0x00, 0x00, 0x80, 0x84, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00};
const uint8_t langBmp38[] PROGMEM = {0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x01, 0x30, 0x00, 0x0F, 0x3C, 0x00, 0x78, 0x00, 0x60, 0x07, 0x20, 0x00, 0x09, 0x6C, 0x00, 0x58, 0x00, 0x30, 0x0C, 0x30, 0x00, 0x0C, 0x60, 0x00, 0xD0, 0x80, 0xE1, 0xCF, 0x1F, 0x78, 0xC7, 0x3B, 0x00, 0x70, 0xE0, 0x23, 0x1C, 0x10, 0x48, 0x44, 0x22, 0x00, 0x78, 0x27, 0x36, 0x18, 0x30, 0x60, 0xE8, 0x63, 0x00, 0xCC, 0x2C, 0x14, 0x90, 0x21, 0x30, 0xE8, 0x61, 0x00, 0x8C, 0x28, 0x14, 0x51, 0x22, 0x98, 0x58, 0x20, 0x00, 0xCC, 0x6C, 0xB6, 0x5B, 0x26, 0x98, 0xC9, 0x30, 0x00, 0x78, 0xC7, 0xE3, 0x4E, 0x3C, 0x70, 0x8F, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00};
const uint8_t langBmp39[] PROGMEM = {0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x03, 0x30, 0x00, 0x80, 0x06, 0x68, 0x00, 0x00, 0x06, 0x78, 0x00, 0xF8, 0x03, 0x70, 0xF0, 0x39, 0x03, 0xB8, 0x13, 0x09, 0x02, 0xEC, 0x16, 0x0D, 0x06, 0x44, 0x14, 0x4D, 0x04, 0xEC, 0xB6, 0xE9, 0x06, 0xB8, 0xE3, 0xB8, 0x03, 0x00, 0x00, 0x00, 0x00};
struct LangBitmap { const char* text; const uint8_t* bitmap; uint8_t width; uint8_t height; };
const LangBitmap langBitmaps[] = {
  {"अंग्रेज़ी", langBmp0, 33, 14},
  {"इतिहास", langBmp1, 40, 15},
  {"इतिहास साफ़ करें", langBmp2, 87, 15},
  {"ईंधन", langBmp3, 23, 15},
  {"उर्वरक", langBmp4, 32, 13},
  {"कन्नड़", langBmp5, 27, 11},
  {"कपास", langBmp6, 32, 9},
  {"गेहूँ", langBmp7, 16, 17},
  {"चावल", langBmp8, 30, 9},
  {"दालें", langBmp9, 21, 14},
  {"पिछला इतिहास", langBmp10, 78, 15},
  {"पिछला मूल्य", langBmp11, 61, 17},
  {"प्रभाव", langBmp12, 29, 9},
  {"बदलाव", langBmp13, 36, 10},
  {"भाषाएँ", langBmp14, 33, 16},
  {"मक्का", langBmp15, 31, 9},
  {"वर्तमान मूल्य", langBmp16, 62, 17},
  {"वापस", langBmp17, 29, 9},
  {"संसाधन", langBmp18, 39, 12},
  {"हिन्दी", langBmp19, 27, 15},
  {"ಅಕ್ಕಿ", langBmp20, 22, 15},
  {"ಇಂಗ್ಲಿಷ್", langBmp21, 44, 15},
  {"ಇಂಧನ", langBmp22, 37, 13},
  {"ಇತಿಹಾಸ", langBmp23, 45, 12},
  {"ಇತಿಹಾಸ ಅಳಿಸಿ", langBmp24, 81, 12},
  {"ಕನ್ನಡ", langBmp25, 29, 16},
  {"ಗೋಧಿ", langBmp26, 34, 13},
  {"ಪರಿಣಾಮ", langBmp27, 55, 11},
  {"ಪ್ರಸ್ತುತ ಬೆಲೆ", langBmp28, 63, 16},
  {"ಬದಲಾವಣೆ", langBmp29, 62, 12},
  {"ಬೇಳೆಕಾಳು", langBmp30, 56, 12},
  {"ಭಾಷೆಗಳು", langBmp31, 53, 14},
  {"ಮೆಕ್ಕೆಜೋಳ", langBmp32, 63, 17},
  {"ರಸಗೊಬ್ಬರ", langBmp33, 59, 16},
  {"ಸಂಪನ್ಮೂಲಗಳು", langBmp34, 87, 17},
  {"ಹತ್ತಿ", langBmp35, 21, 15},
  {"ಹಿಂದಿ", langBmp36, 29, 11},
  {"ಹಿಂದಿನ ಇತಿಹಾಸ", langBmp37, 89, 12},
  {"ಹಿಂದಿನ ಬೆಲೆ", langBmp38, 65, 12},
  {"ಹಿಂದೆ", langBmp39, 29, 12},
};
void drawLocalizedText(int x, int baseline, const char* text) {
  if (!text) return;

  // Hindi and Kannada content below the header divider is shifted down 6 px.
  // Header text stays in its original position; English layout is unchanged.
  int adjustedBaseline = baseline;
  if (language != ENGLISH && baseline > 17) {
    adjustedBaseline += 6;
  }

  for (uint16_t i=0; i<sizeof(langBitmaps)/sizeof(langBitmaps[0]); i++) {
    if (strcmp(text, langBitmaps[i].text)==0) {
      int top = adjustedBaseline - langBitmaps[i].height;
      u8g2.drawXBMP(x, top, langBitmaps[i].width, langBitmaps[i].height, langBitmaps[i].bitmap);
      return;
    }
  }
  u8g2.drawStr(x, adjustedBaseline, text); // ASCII fallback; dynamic serial text remains readable
}

// ================================================
// LANGUAGE FUNCTIONS
// ================================================

const char* languageName(int index) {
  if (index < 0 || index >= LANGUAGE_COUNT)
    return "?";

  if (language == ENGLISH)
    return languagesEN[index];

  if (language == HINDI)
    return languagesHI[index];

  return languagesKN[index];
}

const char* homeItem(int index) {
  if (language == ENGLISH) {
    if (index == 0) return "Resources";
    if (index == 1) return "Languages";
    return "History";
  }

  if (language == HINDI) {
    if (index == 0) return "संसाधन";
    if (index == 1) return "भाषाएँ";
    return "इतिहास";
  }

  if (index == 0) return "ಸಂಪನ್ಮೂಲಗಳು";
  if (index == 1) return "ಭಾಷೆಗಳು";
  return "ಇತಿಹಾಸ";
}

const char* backLabel() {
  if (language == ENGLISH) return "Back";
  if (language == HINDI) return "वापस";
  return "ಹಿಂದೆ";
}

const char* clearLabel() {
  if (language == ENGLISH) return "Clear history";
  if (language == HINDI) return "इतिहास साफ़ करें";
  return "ಇತಿಹಾಸ ಅಳಿಸಿ";
}

const char* pastLabel() {
  if (language == ENGLISH) return "Past history";
  if (language == HINDI) return "पिछला इतिहास";
  return "ಹಿಂದಿನ ಇತಿಹಾಸ";
}

const char* resourcesLabel() {
  if (language == ENGLISH) return "Resources";
  if (language == HINDI) return "संसाधन";
  return "ಸಂಪನ್ಮೂಲಗಳು";
}

const char* languagesLabel() {
  if (language == ENGLISH) return "Languages";
  if (language == HINDI) return "भाषाएँ";
  return "ಭಾಷೆಗಳು";
}

const char* historyLabel() {
  if (language == ENGLISH) return "History";
  if (language == HINDI) return "इतिहास";
  return "ಇತಿಹಾಸ";
}

const char* currentLabel() {
  if (language == ENGLISH) return "Current price";
  if (language == HINDI) return "वर्तमान मूल्य";
  return "ಪ್ರಸ್ತುತ ಬೆಲೆ";
}

const char* beforeLabel() {
  if (language == ENGLISH) return "Before price";
  if (language == HINDI) return "पिछला मूल्य";
  return "ಹಿಂದಿನ ಬೆಲೆ";
}

const char* changeLabel() {
  if (language == ENGLISH) return "Change";
  if (language == HINDI) return "बदलाव";
  return "ಬದಲಾವಣೆ";
}

const char* impactLabel() {
  if (language == ENGLISH) return "Impact";
  if (language == HINDI) return "प्रभाव";
  return "ಪರಿಣಾಮ";
}

// ================================================
// RESOURCE NAME SELECTOR
// ================================================

const char* resourceName(int index) {
  if (index < 0 || index >= RESOURCE_COUNT)
    return "?";

  if (language == ENGLISH)
    return resourcesEN[index];

  if (language == HINDI)
    return resourcesHI[index];

  return resourcesKN[index];
}

// ================================================
// MENU LENGTH
// ================================================

int menuLength() {
  switch (screen) {
    case HOME:
      return 3;

    case RESOURCES:
      return RESOURCE_COUNT + 1;

    case LANGUAGES:
      return LANGUAGE_COUNT + 1;

    case HISTORY:
      return 3;

    default:
      return 1;
  }
}

// ================================================
// MENU TEXT
// ================================================

const char* menuText(int index) {
  switch (screen) {
    case HOME:
      return homeItem(index);

    case RESOURCES:
      if (index < RESOURCE_COUNT)
        return resourceName(index);
      return backLabel();

    case LANGUAGES:
      if (index < LANGUAGE_COUNT)
        return languageName(index);
      return backLabel();

    case HISTORY:
      if (index == 0)
        return pastLabel();

      if (index == 1)
        return clearLabel();

      return backLabel();

    default:
      return "";
  }
}

// ================================================
// HEADER
// ================================================

void drawHeader(const char* title) {
  u8g2.setFont(u8g2_font_6x12_tf);
  drawLocalizedText(2, 14, title);
  u8g2.drawHLine(0, 17, 128);
}

// ================================================
// MENU DRAWING
// ================================================

void drawMenuList() {
  const int visibleRows = 3;
  const int total = menuLength();

  int start = 0;

  if (total > visibleRows) {
    start = selection - 1;

    if (start < 0)
      start = 0;

    if (start > total - visibleRows)
      start = total - visibleRows;
  }

  for (int row = 0; row < visibleRows; row++) {
    int item = start + row;

    if (item >= total)
      break;

    int y = 26 + row * 16;

    if (item == selection) {
      int highlightOffset = (language == ENGLISH) ? 0 : 6;
      u8g2.drawBox(0, y - 14 + highlightOffset, 128, 15);
      u8g2.setDrawColor(0);
      drawLocalizedText(3, y, menuText(item));
      u8g2.setDrawColor(1);
    }
    else {
      drawLocalizedText(3, y, menuText(item));
    }
  }
}

// ================================================
// HOME
// ================================================

void drawHome() {
  drawHeader("AGRICLOUD");
  drawMenuList();
}

void drawResources() {
  drawHeader(resourcesLabel());
  drawMenuList();
}

void drawLanguages() {
  drawHeader(languagesLabel());
  drawMenuList();
}

void drawHistory() {
  drawHeader(historyLabel());
  drawMenuList();
}

// ================================================
// RESOURCE DETAILS
// ================================================

void drawResourceDetails() {
  drawHeader(resourceName(selectedResource));

  u8g2.setFont(u8g2_font_5x8_tf);

  float currentPrice = currentPrices[selectedResource];
  float previousPrice = previousPrices[selectedResource];
  float changePercent = (previousPrice != 0)
    ? ((currentPrice - previousPrice) / previousPrice) * 100.0 : 0;

  drawLocalizedText(2, 24, currentLabel());
  u8g2.setCursor(84, 24);
  u8g2.print(currentPrice, 2);
  u8g2.print(priceUnits[selectedResource]);

  drawLocalizedText(2, 34, beforeLabel());
  u8g2.setCursor(84, 34);
  if (previousPrice > 0) {
    u8g2.print(previousPrice, 2);
    u8g2.print(priceUnits[selectedResource]);
  } else {
    u8g2.print("N/A");
  }

  drawLocalizedText(2, 44, changeLabel());
  u8g2.setCursor(84, 44);
  if (previousPrice > 0) {
    u8g2.print(changePercent, 2);
    u8g2.print("%");
  } else {
    u8g2.print("N/A");
  }

  drawLocalizedText(2, 54, impactLabel());
  drawLocalizedText(2, 62, impactEvent.c_str());

  drawLocalizedText(100, 11, backLabel());
}

// ================================================
// HISTORY PAGE
// ================================================

void drawHistoryView() {
  drawHeader(pastLabel());

  u8g2.setFont(u8g2_font_5x8_tf);
  drawLocalizedText(2, 27, historyMessage.c_str());
  drawLocalizedText(2, 61, backLabel());
}

// ================================================
// ALERT
// ================================================

void drawAlert() {
  // High-contrast alert banner and bold alert text.
  u8g2.setFont(u8g2_font_6x13B_tf);
  u8g2.drawBox(0, 0, 128, 16);
  u8g2.setDrawColor(0);
  u8g2.drawStr(3, 12, "AGRICLOUD ALERT");
  u8g2.setDrawColor(1);

  u8g2.setFont(u8g2_font_6x13B_tf);
  u8g2.drawStr(2, 30, alertHeading.c_str());
  u8g2.setFont(u8g2_font_5x8_tf);
  // Simulate bold with a one-pixel overdraw; 5x8B is not
  // included in every U8g2 font build.
  u8g2.drawStr(2, 43, alertMessage.c_str());
  u8g2.drawStr(3, 43, alertMessage.c_str());
  u8g2.setFont(u8g2_font_5x8_tf);
  u8g2.drawStr(2, 61, "Press button to dismiss");
}

// ================================================
// RENDER
// ================================================

void render() {
  u8g2.firstPage();

  do {
    if (alertActive) {
      drawAlert();
    }
    else {
      switch (screen) {
        case HOME:            drawHome();            break;
        case RESOURCES:       drawResources();       break;
        case LANGUAGES:       drawLanguages();      break;
        case HISTORY:         drawHistory();        break;
        case RESOURCE_DETAILS: drawResourceDetails(); break;
        case HISTORY_VIEW:    drawHistoryView();    break;
        case ALERT_PAGE:      drawAlert();          break;
      }
    }
  } while (u8g2.nextPage());
}

// ================================================
// NAVIGATION
// ================================================

void readNavigation() {
  if (alertActive)
    return;

  if (screen == RESOURCE_DETAILS || screen == HISTORY_VIEW)
    return;

  int raw = analogRead(NAV_PIN);

  if (!navigationInitialized) {
    filteredValue = raw;
    navigationInitialized = true;
  }

  filteredValue = (filteredValue * 3 + raw) / 4;

  int total = menuLength();

  if (total <= 1)
    return;

  int newSelection = ((long)filteredValue * total) / 1024;
  newSelection = constrain(newSelection, 0, total - 1);

  if (newSelection != selection) {
    if (newSelection != candidateSelection) {
      candidateSelection = newSelection;
      candidateStartTime = millis();
    }

    if (millis() - candidateStartTime >= NAV_STABILITY_TIME) {
      selection = candidateSelection;
      candidateSelection = -1;
      render();
    }
  }
  else {
    candidateSelection = -1;
  }
}

// ================================================
// CHANGE LANGUAGE
// ================================================

void setLanguage(Language newLanguage) {
  language = newLanguage;
  screen = LANGUAGES;  // stay on language selection menu
  candidateSelection = -1;
  render();
}

// ================================================
// BUTTON ACTION
// ================================================

void buttonAction() {
  if (alertActive) {
    alertActive = false;
    noTone(BUZZER_PIN);
    screen = HOME;
    selection = 0;
    candidateSelection = -1;
    render();
    return;
  }

  switch (screen) {
    case HOME:
      if (selection == 0) {
        screen = RESOURCES;
        selection = 0;
      }
      else if (selection == 1) {
        screen = LANGUAGES;
        selection = 0;
      }
      else {
        screen = HISTORY;
        selection = 0;
      }
      break;

    case RESOURCES:
      if (selection == RESOURCE_COUNT) {
        screen = HOME;
        selection = 0;
      }
      else {
        selectedResource = selection;
        screen = RESOURCE_DETAILS;
      }
      break;

    case LANGUAGES:
      if (selection == 0) {
        setLanguage(ENGLISH);
        return;
      }
      else if (selection == 1) {
        setLanguage(HINDI);
        return;
      }
      else if (selection == 2) {
        setLanguage(KANNADA);
        return;
      }
      else {
        screen = HOME;
        selection = 0;
      }
      break;

    case HISTORY:
      if (selection == 0) {
        screen = HISTORY_VIEW;
      }
      else if (selection == 1) {
        historyMessage = "History cleared";
        screen = HISTORY;
        selection = 0;
      }
      else {
        screen = HOME;
        selection = 0;
      }
      break;

    case RESOURCE_DETAILS:
      screen = RESOURCES;
      selection = selectedResource;
      break;

    case HISTORY_VIEW:
      screen = HISTORY;
      selection = 0;
      break;

    default:
      screen = HOME;
      selection = 0;
      break;
  }

  candidateSelection = -1;
  render();
}

// ================================================
// BUTTON DEBOUNCE
// ================================================

void readButton() {
  bool reading = digitalRead(BUTTON_PIN);

  if (reading != lastButtonReading)
    lastDebounceTime = millis();

  if (millis() - lastDebounceTime > DEBOUNCE_DELAY) {
    if (reading != stableButtonState) {
      stableButtonState = reading;

      if (stableButtonState == LOW)
        buttonAction();
    }
  }

  lastButtonReading = reading;
}

// ================================================
// COMMAND HANDLING (USB SERIAL + BLUETOOTH LE)
// ================================================

void processCommand(String cmd) {
  cmd.trim();
  if (cmd.length() == 0) return;

  if (cmd == "ALERT:MAJOR") {
    alertHeading = "MAJOR IMPACT";
    alertMessage = "Agricultural impact detected";
    alertActive = true;
    tone(BUZZER_PIN, 2200);
    screen = ALERT_PAGE;
    render();
  }
  else if (cmd == "ALERT:CLEAR") {
    alertActive = false;
    noTone(BUZZER_PIN);
    screen = HOME;
    selection = 0;
    render();
  }
  else if (cmd.startsWith("PRICE:")) {
    String data = cmd.substring(6);
    int p1 = data.indexOf(':');
    int p2 = data.indexOf(':', p1 + 1);
    if (p1 > 0 && p2 > p1) {
      currentPrices[selectedResource] = data.substring(0, p1).toFloat();
      previousPrices[selectedResource] = data.substring(p1 + 1, p2).toFloat();
      render();
    }
  }
  else if (cmd.startsWith("EVENT:")) {
    impactEvent = cmd.substring(6);
    render();
  }
  else if (cmd.startsWith("HISTORY:")) {
    historyMessage = cmd.substring(8);
    render();
  }
}

void processSerial() {
  if (!Serial.available()) return;
  String cmd = Serial.readStringUntil('\n');
  processCommand(cmd);
}

void processBluetooth() {
  if (!bleReady) return;
  BLE.poll();
  if (vigilCharacteristic.written()) {
    char message[181];
    int length = vigilCharacteristic.readValue((uint8_t*)message, 180);
    if (length < 0) length = 0;
    if (length > 180) length = 180;
    message[length] = '\0';
    String cmd = String(message);
    processCommand(cmd);
  }
}

// ================================================
// SETUP
// ================================================

void setup() {
  Serial.begin(115200);

  pinMode(NAV_PIN, INPUT);
  pinMode(BUTTON_PIN, INPUT_PULLUP);
  pinMode(BUZZER_PIN, OUTPUT);

  u8g2.begin();
  u8g2.setFontMode(1);
  u8g2.setDrawColor(1);

  // Start BLE peripheral. The LCD/menu remains usable if BLE startup fails.
  if (BLE.begin()) {
    BLE.setLocalName(DEVICE_NAME);
    BLE.setDeviceName(DEVICE_NAME);
    BLE.setAdvertisedService(vigilService);
    vigilService.addCharacteristic(vigilCharacteristic);
    BLE.addService(vigilService);
    vigilCharacteristic.writeValue("READY");
    BLE.advertise();
    bleReady = true;
    Serial.println("VIGIL BLE advertising");
  } else {
    bleReady = false;
    Serial.println("BLE failed to start; USB Serial remains available");
  }

  filteredValue = analogRead(NAV_PIN);
  navigationInitialized = true;

  screen = HOME;
  selection = 0;

  render();
}

// ================================================
// LOOP
// ================================================

void loop() {
  readNavigation();
  readButton();
  processSerial();
  processBluetooth();

  if (alertActive && screen != ALERT_PAGE) {
    screen = ALERT_PAGE;
    render();
  }

  delay(5);
}
